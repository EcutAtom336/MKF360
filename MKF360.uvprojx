# Keil uVision project MKF360.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: MKF360 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: LWRB_DEV HAVE_CONFIG_H
  c misc: -DLWRB_DISABLE_ATOMIC
  c include: .\lib\CherryUSB-1.5.2\core;.\lib\CherryUSB-1.5.2\common;.\lib\CherryUSB-1.5.2\port\dwc2;.\lib\CherryUSB-1.5.2\class\audio;.\lib\CherryUSB-1.5.2\class\cdc;.\User\include;.\audio\include;.\lib\lwrb-3.2.0\lwrb\src\include;.\lib\speexdsp\include\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\ld\ld_ext.sct
  group User
    ./User/: usb_desc.c retarget.c audio_iis.c audio_dac.c audio_adc.c event_group.c audio_io.c audio_buffer.c audio_processor.c audio_dfsdm.c isr_router.c my_memcpy.c share_buffer.c
  group :CubeMX:CubeMX
    ./STM32CubeMX/Target_1/STM32CubeMX/Src/: main.c gpio.c stm32h7xx_it.c stm32h7xx_hal_msp.c system_stm32h7xx.c quadspi.c dfsdm.c dma.c usart.c dac.c tim.c i2s.c adc.c bdma.c
    ./STM32CubeMX/Target_1/STM32CubeMX/MDK-ARM/: startup_stm32h750xx.s
  group :CubeMX:STM32 HAL Driver
    ./STM32CubeMX/Target_1/STM32CubeMX/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c
  group CherryUSB
    ./lib/CherryUSB-1.5.2/core/: usbd_core.c
    ./lib/CherryUSB-1.5.2/class/audio/: usbd_audio.c
    ./lib/CherryUSB-1.5.2/class/cdc/: usbd_cdc_acm.c
    ./lib/CherryUSB-1.5.2/port/dwc2/: usb_glue_st.c usb_dc_dwc2.c
  group audio
    ./audio/src/: BATTERY_LOW_PCM.c BLUETOOTH_CONNECT_PCM.c BLUETOOTH_DISCONNECT_PCM.c BOOT_PCM.c
  group lwrb
    ./lib/lwrb-3.2.0/lwrb/src/lwrb/: lwrb.c lwrb_ex.c
  group SpeexDSP
    ./lib/speexdsp/libspeexdsp/: buffer.c fftwrap.c filterbank.c jitter.c kiss_fft.c kiss_fftr.c mdf.c preprocess.c resample.c scal.c smallft.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2, Device:CubeMX 1.0.0
